# Keil uVision project PlcMcuModbusCommunication.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: PlcMcuModbusCommunication +hex
  c flags: Optimize=9 SizeSpeed=1
  group USER
    ./: SER_DAC.c
